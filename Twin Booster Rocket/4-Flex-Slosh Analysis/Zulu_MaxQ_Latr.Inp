BATCH MODE INSTRUCTIONS ...............                                                             
Batch for calculating the Lateral Models for the Zulu Rocket
! This batch set creates a state-space model for a flexible Zulu rocket during first stage
! with fuel sloshing at Max-Q and then extracts the lateral subsystem. It generates two
! vehicle systems: a rigid-body model, and a flex model with slosh. It also creates 
! state-space systems for the angle of attack estimator, the flight control system, 
! and the closed-loop system. The state-space systems are converted to Matlab format.
! 
Flight Vehicle   : Zulu, Stage-1, Max-Q, Rigid Body                
Flight Vehicle   : Zulu, Stage-1, Max-Q, 7 Flex Modes with Slosh
System Modificat : Zulu, Stage-1, Max-Q, Lateral Rigid Body  
System Modificat : Zulu, Stage-1, Max-Q, 7 Flex Modes with Slosh, Roll & Yaw Axes  
Mixing Matrix    : Lateral Mixing Logic Matrix for the Twin Engine Zulu Rocket
System Connection: Lateral Design Model 
Actuator Model   : Engine TVC Actuator
!
To Matlab Format : Zulu, Stage-1, Max-Q, Lateral Rigid Body
To Matlab Format : Zulu, Stage-1, Max-Q, 7 Flex Modes with Slosh, Roll & Yaw Axes
To Matlab Format : Lateral Mixing Logic Matrix for the Twin Engine Zulu Rocket
To Matlab Format : Lateral Design Model 
To Matlab Format : Engine TVC Actuator
----------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Zulu, Stage-1, Max-Q, Rigid Body                                                  
! This is a rigid launch vehicle model during First Stage at Maximum Dynamic Pressure. 
! It is released from a high altitude to maximize orbit performance. At Max-Q and while 
! flying at Mach 2.5 it experiences a strong wind shear that causes 4 deg of angle of attack. 
! The vehicle has two side boosters that can provide 353,000 (lb) of thrust each.
!
Body Axes Output,Attitude=Euler Angles,Without GAFD, No Turn Coordination  
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   9580.00       32.1740      0.208960E+08
Moments and Products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   519316.      0.171345E+07  0.215335E+07  -671.961       3512.52       377.182    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :  -226.098       0.00000       0.006928
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   1.94000       1870.00       228.000       71300.0    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   45.4546       75.0000       0.00000       1.30000    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :  -1.94000       0.00000       0.50000       0.00000    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.00000       48.1600       0.00000       0.00000     -0.225000       0.00000    
W-Gust Azim & Elev angles (deg), or Torque/Force direction (x,y,z), Force Locat (x,y,z)  :   Gust          45.0000       45.0000                                             
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   47.3080       7.76100       7.76100    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :  -228.190       0.00000       0.00000       0.00000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:   0.75011      0.0014        -0.182727E-03  0.00000       0.00000       0.00000       0.00000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.00000     -0.065940       0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:   0.66564     -0.343600       0.00000       0.00000       0.00000       0.00000     -0.940912E-05
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.00000     -0.006900       0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:  -1.30220      0.680650       0.00000       0.00000       0.00000      0.182591E-03   0.00000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.00000     -0.278360       0.00000       0.00000       0.00000       0.00000    

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  0   NO TWD  


Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  2   NO TWD

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : Left TVC         Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  363305.0      363305.0  
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):   0.0          0.0          5.0          5.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   47.0         260.00       0.2  
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  -244.62      -8.67         0.0    
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : Right TVC        Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  363305.0      363305.0  
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):   0.0          0.0          5.0          5.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   47.0         260.00       0.2  
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  -244.62       8.67         0.0                                     
----------------------------------------------------------------------------------------------------------------------------
MIXING LOGIC MATRIX DATA ..........    (Matrix Title, Name, Vehicle Title, Control Directions)
Lateral Mixing Logic Matrix for the Twin Engine Zulu Rocket             
! Mixing Logic Matrix for the Twin Engine Zulu Rocket at Max-Q 
Kmix
Zulu, Stage-1, Max-Q, Rigid Body
P-dot Roll  Acceleration About X Axis                                           
R-dot Yaw   Acceleration About Z Axis                                           
----------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Zulu, Stage-1, Max-Q, Lateral Rigid Body                                               
Zulu, Stage-1, Max-Q, Rigid Body                                                             
! The lateral rigid body system is extracted from the coupled RB system above                                     
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract States :   1   2   5   6   8  
Extract Outputs:   1   2   5   6   8  13
------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Lateral Design Model 
! Create a Lateral Design Model that includes the Mixing-Logic matrix Kmix,
! to be used in the LQR design           
Titles of Systems to be Combined  
Title 1 Zulu, Stage-1, Max-Q, Lateral Rigid Body 
SYSTEM INPUTS TO SUBSYSTEM  1
Via Matrix +Kmix                                                                The (4x2) Mixing Logic Matrix
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                Lateral State-Vector Outputs
Via Matrix +I5
..............................................................................
Definitions of Inputs  =   2
P-dot Roll  Acceleration About X Axis                                           
R-dot Yaw   Acceleration About Z Axis                                           
 
Definitions of Outputs =   5
Roll Attitude  (phi-body) (radians)                                                          
Roll Rate      (p-body)   (rad/sec)                                                          
Yaw  Attitude  (psi-body) (radians)                                                          
Yaw  Rate      (r-body)   (rad/sec)                                                          
Angle of sideslip, beta, (radian)                                                            
-----------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Zulu, Stage-1, Max-Q, 7 Flex Modes with Slosh                                                  
! This is a Launch Vehicle during First Stage at Maximum Dynamic Pressure. It is released from    
! a high altitude to maximize orbit performance. At Max-Q and while flying at Mach 2.5 it
! experiences a strong wind shear that causes 4 deg of angle of attack. The vehicle has two side
! liquid propellant rockets that can provide 320,000 (lb) of thrust each. The two fuel tanks, one
! on each side, cause a significant amount of slosh disturbance.
!
Body Axes Output,Attitude=Euler Angles,Without GAFD, No Turn Coordination  
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   9580.00       32.1740      0.208960E+08
Moments and Products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   519316.      0.171345E+07  0.215335E+07  -671.961       3512.52       377.182    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :  -226.098       0.00000       0.006928
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   1.94000       1870.00       228.000       71300.0    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   45.4546       75.0000       0.00000       1.30000    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :  -1.94000       0.00000       0.50000       0.00000    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.00000       48.1600       0.00000       0.00000     -0.225000       0.00000    
W-Gust Azim & Elev angles (deg), or Torque/Force direction (x,y,z), Force Locat (x,y,z)  :   Gust          45.0000       45.0000                                             
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   47.3080       7.76100       7.76100    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :  -228.190       0.00000       0.00000       0.00000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:   0.75011      0.0014        -0.182727E-03  0.00000       0.00000       0.00000       0.00000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.00000     -0.065940       0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:   0.66564     -0.343600       0.00000       0.00000       0.00000       0.00000     -0.940912E-05
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.00000     -0.006900       0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:  -1.30220      0.680650       0.00000       0.00000       0.00000      0.182591E-03   0.00000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.00000     -0.278360       0.00000       0.00000       0.00000       0.00000    

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  2   WITH TWD

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : Left TVC         Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  363305.0      363305.0      
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.0           0.0          5.0          5.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   47.0         260.00       0.2  
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  -244.62      -8.67         0.0    
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : Right TVC        Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  363305.0      363305.0      
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.0           0.0          5.0          5.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   47.0         260.00       0.2  
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  -244.62       8.67         0.0                                     

Number of Gyros, (Attitude and Rate)                                                     :  3
Gyro No  1 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Roll   Rate           -222.00      0.00      0.00    
Gyro No  2 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Pitch  Rate           -222.00      0.00      0.00    
Gyro No  3 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Yaw    Rate           -222.00      0.00      0.00    

Number of Accelerometers, Along Axis: (x,y,z)                                            :  2
Acceleromet No  1 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Y-axis Accelerat.     -225.00      0.00      0.00    
Acceleromet No  2 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Z-axis Accelerat.     -225.00      0.00      0.00    

Number of Vane Sensors, (Measuring Alpha or Beta)                                        :  0

Number of Slosh Modes                                                                    :  2
Left Tank (slug), Frequ Wy,Wz at 1g (rad/s), Damping (zeta-y-z), Locat {Xsl,Ysl,Zsl} (ft):  350.0   2.43  2.43  0.001  0.001  -235.00  -8.7000   0.0000    
Rght Tank (slug), Frequ Wy,Wz at 1g (rad/s), Damping (zeta-y-z), Locat {Xsl,Ysl,Zsl} (ft):  350.0   2.43  2.43  0.001  0.001  -235.00   8.7000   0.0000    

Number of Bending Modes                                                                  :  7
Zulu, Stage-1, Max-Q, 7 Flex Modes, Roll Modes                                    
----------------------------------------------------------------------------------------------------------------------------
SELECTED MODAL DATA AND LOCATIONS FOR THE ROLL AXIS          
Zulu, Stage-1, Max-Q, 7 Flex Modes, Roll Modes
! The roll modes were selected by applying a -Z force at the left gimbal and +Z force at the  
! right gimbal. The roll rotation was sensed at the IMU node. We included also modal data 
! at the two TVC gimbals, the 3 roll, pitch, and yaw gyros, and the two (Ny and Nz) acceleromet.    
! The modal data were also scaled as in pitch from the original Nastran output in (*.mod) file. 

MODE # 1/  1, Frequency (rad/sec), Damping (zeta), Generalized Mass=    20.449       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  2 Engines, (x,y,z)...
Left  (-y) Boster Gimbal Locat   35701    -0.25060D-01   0.10089D-01  -0.48000D-03   0.23400D-04  -0.24816D-04  -0.12228D-02
Right (+y) Boster Gimbal Locat   45701     0.25080D-01   0.10093D-01  -0.98000D-04   0.22764D-04  -0.21000D-04  -0.12233D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Nav Base (IMU , Accelerom)       95602    -0.13080D-05   0.23100D-01   0.18520D-03  -0.60120D-04   0.17244D-04   0.36600D-02
Nav Base (IMU , Accelerom)       95602    -0.13080D-05   0.23100D-01   0.18520D-03  -0.60120D-04   0.17244D-04   0.36600D-02
Nav Base (IMU , Accelerom)       95602    -0.13080D-05   0.23100D-01   0.18520D-03  -0.60120D-04   0.17244D-04   0.36600D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Nav Base (IMU , Accelerom)       95602    -0.13080D-05   0.23100D-01   0.18520D-03
Nav Base (IMU , Accelerom)       95602    -0.13080D-05   0.23100D-01   0.18520D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
Left  Booster Liquid Oxygen Sl   81602    -0.90090D-02   0.51000D-02   0.26000D-03  -0.33480D-05   0.24360D-04   0.26904D-02
Right Booster Liquid Oxygen Sl   88603     0.90170D-02   0.50960D-02   0.34470D-03  -0.40680D-05  -0.83160D-05   0.26904D-02

                              Node ID#     Modal Data at the Disturbance Point 
Middle Boster Gimbal Location    55701     0.42000D-05   0.59180D-02  -0.23980D-03   0.16020D-04  -0.23688D-04  -0.12876D-02

MODE # 2/  7, Frequency (rad/sec), Damping (zeta), Generalized Mass=    56.352       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  2 Engines, (x,y,z)...
Left  (-y) Boster Gimbal Locat   35701    -0.55830D-02  -0.22940D-01  -0.11260D-03  -0.50400D-04  -0.16440D-05   0.17640D-02
Right (+y) Boster Gimbal Locat   45701     0.55940D-02  -0.23080D-01  -0.21500D-02  -0.12648D-03  -0.11748D-03   0.17520D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Nav Base (IMU , Accelerom)       95602     0.22600D-05  -0.53860D-01  -0.34460D-02   0.37320D-03   0.12600D-03  -0.32880D-02
Nav Base (IMU , Accelerom)       95602     0.22600D-05  -0.53860D-01  -0.34460D-02   0.37320D-03   0.12600D-03  -0.32880D-02
Nav Base (IMU , Accelerom)       95602     0.22600D-05  -0.53860D-01  -0.34460D-02   0.37320D-03   0.12600D-03  -0.32880D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Nav Base (IMU , Accelerom)       95602     0.22600D-05  -0.53860D-01  -0.34460D-02
Nav Base (IMU , Accelerom)       95602     0.22600D-05  -0.53860D-01  -0.34460D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
Left  Booster Liquid Oxygen Sl   81602     0.15387D-01  -0.26460D-01  -0.14220D-02   0.29880D-03   0.25800D-03  -0.51720D-02
Right Booster Liquid Oxygen Sl   88603    -0.15454D-01  -0.26380D-01  -0.35440D-02   0.28680D-03   0.26040D-03  -0.51600D-02

                              Node ID#     Modal Data at the Disturbance Point 
Middle Boster Gimbal Location    55701     0.97500D-04  -0.27340D-01  -0.93730D-03  -0.28608D-04  -0.42000D-03   0.47640D-02

MODE # 3/  9, Frequency (rad/sec), Damping (zeta), Generalized Mass=    62.784       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  2 Engines, (x,y,z)...
Left  (-y) Boster Gimbal Locat   35701     0.36200D-02   0.20900D-01  -0.55600D-02   0.11640D-03  -0.45240D-03  -0.15480D-02
Right (+y) Boster Gimbal Locat   45701    -0.36600D-02   0.20800D-01  -0.19600D-02   0.11640D-03  -0.21600D-03  -0.15360D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Nav Base (IMU , Accelerom)       95602     0.14400D-03   0.47400D-01  -0.82100D-02  -0.37920D-03   0.15600D-03   0.15840D-02
Nav Base (IMU , Accelerom)       95602     0.14400D-03   0.47400D-01  -0.82100D-02  -0.37920D-03   0.15600D-03   0.15840D-02
Nav Base (IMU , Accelerom)       95602     0.14400D-03   0.47400D-01  -0.82100D-02  -0.37920D-03   0.15600D-03   0.15840D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Nav Base (IMU , Accelerom)       95602     0.14400D-03   0.47400D-01  -0.82100D-02
Nav Base (IMU , Accelerom)       95602     0.14400D-03   0.47400D-01  -0.82100D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
Left  Booster Liquid Oxygen Sl   81602    -0.11800D-01   0.29000D-01  -0.80200D-02  -0.34560D-03   0.62040D-03   0.40920D-02
Right Booster Liquid Oxygen Sl   88603     0.11900D-01   0.29000D-01  -0.53900D-02  -0.38400D-03   0.57720D-03   0.41040D-02

                              Node ID#     Modal Data at the Disturbance Point 
Middle Boster Gimbal Location    55701     0.35700D-03   0.20500D-01  -0.22800D-02   0.79560D-04   0.36000D-03   0.56160D-03

MODE # 4/ 10, Frequency (rad/sec), Damping (zeta), Generalized Mass=    83.449       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  2 Engines, (x,y,z)...
Left  (-y) Boster Gimbal Locat   35701     0.17600D-03   0.22700D-02  -0.87500D-02  -0.92400D-02  -0.36600D-03  -0.12720D-03
Right (+y) Boster Gimbal Locat   45701    -0.25900D-03   0.23600D-02   0.96300D-02  -0.92760D-02   0.41640D-03  -0.19800D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Nav Base (IMU , Accelerom)       95602     0.83500D-05   0.48500D-02   0.45000D-03   0.10752D-01   0.13800D-03  -0.11292D-02
Nav Base (IMU , Accelerom)       95602     0.83500D-05   0.48500D-02   0.45000D-03   0.10752D-01   0.13800D-03  -0.11292D-02
Nav Base (IMU , Accelerom)       95602     0.83500D-05   0.48500D-02   0.45000D-03   0.10752D-01   0.13800D-03  -0.11292D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Nav Base (IMU , Accelerom)       95602     0.83500D-05   0.48500D-02   0.45000D-03
Nav Base (IMU , Accelerom)       95602     0.83500D-05   0.48500D-02   0.45000D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
Left  Booster Liquid Oxygen Sl   81602     0.25100D-03   0.72000D-02   0.37800D-01   0.91320D-02  -0.36000D-03   0.62400D-05
Right Booster Liquid Oxygen Sl   88603    -0.22800D-03   0.71600D-02  -0.35200D-01   0.91080D-02   0.33120D-03  -0.28320D-05

                              Node ID#     Modal Data at the Disturbance Point 
Middle Boster Gimbal Location    55701    -0.45000D-04   0.19400D-02   0.17000D-03   0.76200D-02   0.20280D-04  -0.19320D-03

MODE # 5/ 11, Frequency (rad/sec), Damping (zeta), Generalized Mass=    93.186       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  2 Engines, (x,y,z)...
Left  (-y) Boster Gimbal Locat   35701     0.69400D-03   0.89700D-02  -0.80700D-02   0.48720D-02  -0.12000D-02  -0.62400D-03
Right (+y) Boster Gimbal Locat   45701    -0.64200D-03   0.88000D-02   0.70200D-02   0.49800D-02   0.10812D-02  -0.65040D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Nav Base (IMU , Accelerom)       95602    -0.96500D-05   0.11000D-01   0.24800D-05   0.21000D-02  -0.34080D-03  -0.57600D-02
Nav Base (IMU , Accelerom)       95602    -0.96500D-05   0.11000D-01   0.24800D-05   0.21000D-02  -0.34080D-03  -0.57600D-02
Nav Base (IMU , Accelerom)       95602    -0.96500D-05   0.11000D-01   0.24800D-05   0.21000D-02  -0.34080D-03  -0.57600D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Nav Base (IMU , Accelerom)       95602    -0.96500D-05   0.11000D-01   0.24800D-05
Nav Base (IMU , Accelerom)       95602    -0.96500D-05   0.11000D-01   0.24800D-05

                              Node ID#     Modal Data at the  2 Slosh Masses...
Left  Booster Liquid Oxygen Sl   81602     0.47200D-02   0.32870D-01  -0.20600D-02   0.49080D-03  -0.85560D-03  -0.13200D-02
Right Booster Liquid Oxygen Sl   88603    -0.47700D-02   0.32710D-01  -0.19770D-02   0.46200D-03   0.45960D-03  -0.13440D-02

                              Node ID#     Modal Data at the Disturbance Point 
Middle Boster Gimbal Location    55701     0.25700D-04   0.67000D-02  -0.13400D-03  -0.18600D-02  -0.80760D-04  -0.85560D-03

MODE # 6/ 12, Frequency (rad/sec), Damping (zeta), Generalized Mass=    96.019       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  2 Engines, (x,y,z)...
Left  (-y) Boster Gimbal Locat   35701     0.13800D-03   0.26000D-02  -0.32400D-02  -0.32880D-02   0.27000D-03  -0.16920D-03
Right (+y) Boster Gimbal Locat   45701    -0.17800D-03   0.22700D-02  -0.10780D-01  -0.46560D-03  -0.84480D-03  -0.12360D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Nav Base (IMU , Accelerom)       95602     0.15300D-03   0.23500D-02   0.28200D-02  -0.14640D-02  -0.55560D-02  -0.12360D-02
Nav Base (IMU , Accelerom)       95602     0.15300D-03   0.23500D-02   0.28200D-02  -0.14640D-02  -0.55560D-02  -0.12360D-02
Nav Base (IMU , Accelerom)       95602     0.15300D-03   0.23500D-02   0.28200D-02  -0.14640D-02  -0.55560D-02  -0.12360D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Nav Base (IMU , Accelerom)       95602     0.15300D-03   0.23500D-02   0.28200D-02
Nav Base (IMU , Accelerom)       95602     0.15300D-03   0.23500D-02   0.28200D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
Left  Booster Liquid Oxygen Sl   81602     0.11800D-02   0.95900D-02  -0.32700D-01  -0.62160D-03  -0.23400D-02  -0.41160D-03
Right Booster Liquid Oxygen Sl   88603    -0.13400D-02   0.95900D-02  -0.27970D-01  -0.98160D-03  -0.23640D-02  -0.39360D-03

                              Node ID#     Modal Data at the Disturbance Point 
Middle Boster Gimbal Location    55701     0.35000D-03   0.17800D-02  -0.16400D-02   0.44880D-03  -0.12240D-02  -0.22560D-03

MODE # 7/ 13, Frequency (rad/sec), Damping (zeta), Generalized Mass=    109.77       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  2 Engines, (x,y,z)...
Left  (-y) Boster Gimbal Locat   35701     0.54000D-03   0.15100D-01   0.20300D-01  -0.90840D-02   0.33600D-02  -0.67200D-03
Right (+y) Boster Gimbal Locat   45701     0.58000D-03  -0.13700D-01   0.15000D-01   0.78720D-02   0.26400D-02   0.46800D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Nav Base (IMU , Accelerom)       95602    -0.34000D-02  -0.45100D-03   0.13900D-01  -0.15000D-02   0.55440D-03  -0.46200D-03
Nav Base (IMU , Accelerom)       95602    -0.34000D-02  -0.45100D-03   0.13900D-01  -0.15000D-02   0.55440D-03  -0.46200D-03
Nav Base (IMU , Accelerom)       95602    -0.34000D-02  -0.45100D-03   0.13900D-01  -0.15000D-02   0.55440D-03  -0.46200D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Nav Base (IMU , Accelerom)       95602    -0.34000D-02  -0.45100D-03   0.13900D-01
Nav Base (IMU , Accelerom)       95602    -0.34000D-02  -0.45100D-03   0.13900D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
Left  Booster Liquid Oxygen Sl   81602    -0.21000D-02   0.29000D-02   0.10000D-01  -0.14040D-02  -0.18000D-02  -0.26400D-03
Right Booster Liquid Oxygen Sl   88603    -0.37000D-02   0.27000D-02   0.19100D-01  -0.11088D-02  -0.15600D-02  -0.28800D-03

                              Node ID#     Modal Data at the Disturbance Point 
Middle Boster Gimbal Location    55701     0.15000D-03   0.37800D-03  -0.10000D-02  -0.55080D-03  -0.20400D-02  -0.78000D-04
----------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Zulu, Stage-1, Max-Q, 7 Flex Modes with Slosh, Roll & Yaw Axes
Zulu, Stage-1, Max-Q, 7 Flex Modes with Slosh                                                
! The lateral system is extracted from the coupled system above                                     
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract States :   1   2   5   6   8  11  12  13  14  15  16  17  18  19  20  21  22  23  24  25  26  27  28  29  30  31  32
Extract Outputs:   1   2   5   6   8  12  14  15  17  18  19  20
----------------------------------------------------------------------------------------------------------------------------
ACTUATOR INPUT DATA ............ SIMPLE GENERIC MODEL     
Engine TVC Actuator
Symbol Parameter Description                    (Units)      Value 
C(s)   Order of Compensat:(0,1,2), Coefficients   (---)      1, 0.005, 0.05
Kc     Input Command Gain ..................... (volt/rad)   3.0    
Ka     Gain of Amplifier ...................... (amps/volt)  60.0    
Ksv    Closed-Loop Actuator Servo Gain ....... (ft/sec/amp)  1.0
Kact   Actuator Stiffness (Piston+Oil+Electric) (lb/ft)      0.48e+8
Klod   Load Stiffness,(Con. Surface or Nozzle)  (lb/ft)      0.36e+10
Kbck   Vehicle Backup Structure Stiffness ....  (lb/ft)      0.84e+10
R      Moment Arm of Actuator Rod from Gimbal..  (feet)      3.0
Jl     Load Inertia about the Gimbal .......... (ft-lb-s^2)  3200.0
Kg     Load Gimbal Bearing Spring Constant      (ft-lb/rad)  0.0000    
Bg     Load Gimbal Bearing Viscous Damping .... (ft-lb-sec)  75000.0
Kfb    Actuator Position Feedback Gain ........ (volts/ft)   1.0
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Zulu, Stage-1, Max-Q, Lateral Rigid Body                                      
System
Vehi_Latr_RB.m
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Zulu, Stage-1, Max-Q, 7 Flex Modes with Slosh, Roll & Yaw Axes                                      
System
Vehi_Latr_Sflx.m
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Lateral Design Model 
System
Latr_des.m
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Lateral Mixing Logic Matrix for the Twin Engine Zulu Rocket                               
Matrix Kmix
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Engine TVC Actuator
System
Actuator
------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
