BATCH MODE INSTRUCTIONS ...............                                                             
Batch for calculating the Closed-Loop model for a Zulu Rocket
! This batch set creates a state-space model for a rigid Zulu rocket during first stage
! at Max-Q and then extracts the longitudinal subsystem. It creates also a flex vehicle 
! model with fuel sloshing and extracts also the longitudinal flex subsystem. It creates also 
! state-space systems for the angle of attack estimator, the flight control system, and the 
! open-loop and closed-loop systems. The systems are converted to Matlab format.
! 
Flight Vehicle   : Zulu, Stage-1, Max-Q, Rigid Body                
System Modificat : Zulu, Stage-1, Max-Q, Rigid Body, Pitch Axis  
Flight Vehicle   : Zulu, Stage-1, Max-Q, 8 Flex Modes with Slosh                
System Modificat : Zulu, Stage-1, Max-Q, 8 Flex Modes with Slosh, Pitch Axis  
Transf-Function  : Alpha Estimator 
Transf-Function  : Pitch Flight Control System 
Actuator Model   : Engine TVC Actuator
System Connection: Pitch Open-Loop System  
System Connection: Pitch Closed-Loop System  
!
To Matlab Format : Zulu, Stage-1, Max-Q, Rigid Body, Pitch Axis
To Matlab Format : Zulu, Stage-1, Max-Q, 8 Flex Modes with Slosh, Pitch Axis
To Matlab Format : Alpha Estimator
To Matlab Format : Pitch Flight Control System
To Matlab Format : Engine TVC Actuator
To Matlab Format : Pitch Open-Loop System
To Matlab Format : Pitch Closed-Loop System
----------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Zulu, Stage-1, Max-Q, Rigid Body                                                  
! This is a Launch Vehicle during First Stage at Maximum Dynamic Pressure. It is launched from    
! a high altitude to maximize orbit performance. At Max-Q and while flying at 2.5 Mach it
! experiences a strong wind shear that causes 4 deg of angle of attack. The vehicle has two side
! liquid oxygen rockets that can provide 363,000 (lb) of thrust each. The two fuel tanks, one
! on each side cause a significant amount of slosh disturbance.
!
Body Axes Output,Attitude=Euler Angles,Without GAFD, No Turn Coordination  
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   9580.00       32.1740      0.208960E+08
Moments and Products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   519316.      0.171345E+07  0.215335E+07  -671.961       3512.52       377.182    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :  -226.098       0.00000       0.006928
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   1.94000       1870.00       228.000       71300.0    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   45.4546       75.0000       0.00000       1.30000    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :  -1.94000       0.00000       0.50000       0.00000    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.00000       48.1600       0.00000       0.00000     -0.225000       0.00000    
W-Gust Azim & Elev angles (deg), or Torque/Force direction (x,y,z), Force Locat (x,y,z)  :   Gust          45.0000       45.0000                                             
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   47.3080       7.76100       7.76100    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :  -228.190       0.00000       0.00000       0.00000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:   0.75011      0.0014        -0.182727E-03  0.00000       0.00000       0.00000       0.00000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.00000     -0.065940       0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:   0.66564     -0.343600       0.00000       0.00000       0.00000       0.00000     -0.940912E-05
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.00000     -0.006900       0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:  -1.30220      0.680650       0.00000       0.00000       0.00000      0.182591E-03   0.00000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.00000     -0.278360       0.00000       0.00000       0.00000       0.00000    

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  0   NO TWD  


Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  2   NO TWD

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : Left TVC         Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  363305.0      363305.0  
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):   0.0          0.0          5.0          5.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   47.0         260.00       0.2  
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  -244.62      -8.67         0.0    
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : Right TVC        Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  363305.0      363305.0  
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):   0.0          0.0          5.0          5.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   47.0         260.00       0.2  
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  -244.62       8.67         0.0                                     
----------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Zulu, Stage-1, Max-Q, Rigid Body, Pitch Axis                                                  
Zulu, Stage-1, Max-Q, Rigid Body                                                  
! Pitch rigid system is extracted from the coupled rigid system above                                      
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   1   2   5
Extract States :   3   4   7 
Extract Outputs:   3   4   7  14
----------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Zulu, Stage-1, Max-Q, 8 Flex Modes with Slosh                                                  
! This is a Launch Vehicle during First Stage at Maximum Dynamic Pressure. It is launched from    
! a high altitude to maximize orbit performance. At Max-Q and while flying at 2.5 Mach it
! experiences a strong wind shear that causes 4 deg of angle of attack. The vehicle has two side
! liquid oxygen rockets that can provide 363,000 (lb) of thrust each. The two fuel tanks, one
! on each side cause a significant amount of slosh disturbance.
!
Body Axes Output,Attitude=Euler Angles,Without GAFD, No Turn Coordination  
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   9580.00       32.1740      0.208960E+08
Moments and Products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   519316.      0.171345E+07  0.215335E+07  -671.961       3512.52       377.182    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :  -226.098       0.00000       0.006928
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   1.94000       1870.00       228.000       71300.0    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   45.4546       75.0000       0.00000       1.30000    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :  -1.94000       0.00000       0.50000       0.00000    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.00000       48.1600       0.00000       0.00000     -0.225000       0.00000    
W-Gust Azim & Elev angles (deg), or Torque/Force direction (x,y,z), Force Locat (x,y,z)  :   Gust          45.0000       45.0000                                             
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   47.3080       7.76100       7.76100    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :  -228.190       0.00000       0.00000       0.00000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:   0.75011      0.0014        -0.182727E-03  0.00000       0.00000       0.00000       0.00000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.00000     -0.065940       0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:   0.66564     -0.343600       0.00000       0.00000       0.00000       0.00000     -0.940912E-05
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.00000     -0.006900       0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:  -1.30220      0.680650       0.00000       0.00000       0.00000      0.182591E-03   0.00000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.00000     -0.278360       0.00000       0.00000       0.00000       0.00000    

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  0   NO TWD  


Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  2   WITH TWD

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : Left TVC         Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  363305.0      363305.0      
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.0           0.0          5.0          5.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   47.0         260.00       0.2  
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  -244.62      -8.67         0.0    
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : Right TVC        Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  363305.0      363305.0      
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.0           0.0          5.0          5.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   47.0         260.00       0.2  
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  -244.62       8.67         0.0                                     

Number of Gyros, (Attitude and Rate)                                                     :  3
Gyro No  1 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Roll   Rate           -222.00      0.00      0.00    
Gyro No  2 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Pitch  Rate           -222.00      0.00      0.00    
Gyro No  3 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Yaw    Rate           -222.00      0.00      0.00    

Number of Accelerometers, Along Axis: (x,y,z)                                            :  2
Acceleromet No  1 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Y-axis Accelerat.     -225.00      0.00      0.00    
Acceleromet No  2 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Z-axis Accelerat.     -225.00      0.00      0.00    

Number of Slosh Modes                                                                    :  2
Left Tank (slug), Frequ Wy,Wz at 1g (rad/s), Damping (zeta-y-z), Locat {Xsl,Ysl,Zsl} (ft):  350.0   2.43  2.43  0.001  0.001  -235.00  -8.7000   0.0000    
Rght Tank (slug), Frequ Wy,Wz at 1g (rad/s), Damping (zeta-y-z), Locat {Xsl,Ysl,Zsl} (ft):  350.0   2.43  2.43  0.001  0.001  -235.00   8.7000   0.0000    

Number of Bending Modes                                                                  :  8
Zulu, Stage-1, Max-Q, 8 Flex Modes, Pitch Modes                                    
----------------------------------------------------------------------------------------------------------------------------
SELECTED MODAL DATA AND LOCATIONS FOR THE PITCH MODES         
Zulu, Stage-1, Max-Q, 8 Flex Modes, Pitch Modes                                    
! The pitch modes were selected by applying +Z forces at the two gimbals, (same direction at the  
! left and right TVC). The pitch rotation was sensed at the IMU node. We included also modal data 
! at the two TVC gimbals, the 3 roll, pitch, and yaw gyros, and the two (Ny and Nz) acceleromet.    
! The modal data were scaled from the original Nastran output in (*.mod) file. We reverse the
! directions in the X and Z axes. The modal slopes were multiplied by 12 to be converted from       
! (rad/inch) to (radians/foot). The modal masses were multiplied by 12 to be converted from         
! (snails) to (slugs). Standard Nastran to GN&C units transformation (Default).    

MODE # 1/  1, Frequency (rad/sec), Damping (zeta), Generalized Mass=    20.449       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  2 Engines, (x,y,z)...
Left  (-y) Boster Gimbal Locat   35701    -0.25060D-01   0.10089D-01  -0.48000D-03   0.23400D-04  -0.24816D-04  -0.12228D-02
Right (+y) Boster Gimbal Locat   45701     0.25080D-01   0.10093D-01  -0.98000D-04   0.22764D-04  -0.21000D-04  -0.12233D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Nav Base (IMU , Accelerom)       95602    -0.13080D-05   0.23100D-01   0.18520D-03  -0.60120D-04   0.17244D-04   0.36600D-02
Nav Base (IMU , Accelerom)       95602    -0.13080D-05   0.23100D-01   0.18520D-03  -0.60120D-04   0.17244D-04   0.36600D-02
Nav Base (IMU , Accelerom)       95602    -0.13080D-05   0.23100D-01   0.18520D-03  -0.60120D-04   0.17244D-04   0.36600D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Nav Base (IMU , Accelerom)       95602    -0.13080D-05   0.23100D-01   0.18520D-03
Nav Base (IMU , Accelerom)       95602    -0.13080D-05   0.23100D-01   0.18520D-03

                              Node ID#     Modal Data at the  2 Slosh Masses...
Left  Booster Liquid Oxygen Sl   81602    -0.90090D-02   0.51000D-02   0.26000D-03  -0.33480D-05   0.24360D-04   0.26904D-02
Right Booster Liquid Oxygen Sl   88603     0.90170D-02   0.50960D-02   0.34470D-03  -0.40680D-05  -0.83160D-05   0.26904D-02

                              Node ID#     Modal Data at the Disturbance Point 
Nav Base (IMU , Accelerom)       95602    -0.13080D-05   0.23100D-01   0.18520D-03  -0.60120D-04   0.17244D-04   0.36600D-02

MODE # 2/  2, Frequency (rad/sec), Damping (zeta), Generalized Mass=    22.271       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  2 Engines, (x,y,z)...
Left  (-y) Boster Gimbal Locat   35701    -0.26580D-03   0.57370D-04   0.25310D-01   0.12300D-03  -0.19884D-02  -0.15852D-04
Right (+y) Boster Gimbal Locat   45701     0.41850D-03   0.88360D-04   0.25260D-01   0.11760D-03  -0.19872D-02  -0.18912D-04

                              Node ID#     Modal Data at the  3 Gyros ...
Nav Base (IMU , Accelerom)       95602     0.43500D-03   0.45400D-03  -0.10500D-01   0.43200D-05  -0.23088D-02   0.54600D-04
Nav Base (IMU , Accelerom)       95602     0.43500D-03   0.45400D-03  -0.10500D-01   0.43200D-05  -0.23088D-02   0.54600D-04
Nav Base (IMU , Accelerom)       95602     0.43500D-03   0.45400D-03  -0.10500D-01   0.43200D-05  -0.23088D-02   0.54600D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Nav Base (IMU , Accelerom)       95602     0.43500D-03   0.45400D-03  -0.10500D-01
Nav Base (IMU , Accelerom)       95602     0.43500D-03   0.45400D-03  -0.10500D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
Left  Booster Liquid Oxygen Sl   81602    -0.12800D-03   0.12550D-03  -0.24500D-01  -0.32760D-04  -0.11892D-02   0.13236D-04
Right Booster Liquid Oxygen Sl   88603     0.15130D-03   0.28260D-03  -0.24510D-01   0.37200D-04  -0.81360D-03   0.70200D-04

                              Node ID#     Modal Data at the Disturbance Point 
Nav Base (IMU , Accelerom)       95602     0.43500D-03   0.45400D-03  -0.10500D-01   0.43200D-05  -0.23088D-02   0.54600D-04

MODE # 3/  5, Frequency (rad/sec), Damping (zeta), Generalized Mass=    45.545       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  2 Engines, (x,y,z)...
Left  (-y) Boster Gimbal Locat   35701    -0.42700D-04   0.98600D-04   0.89500D-02  -0.73920D-02  -0.12144D-02  -0.14040D-04
Right (+y) Boster Gimbal Locat   45701     0.23700D-04   0.51600D-04   0.89800D-02   0.73920D-02  -0.12120D-02  -0.19560D-04

                              Node ID#     Modal Data at the  3 Gyros ...
Nav Base (IMU , Accelerom)       95602     0.12600D-04  -0.94400D-06  -0.12225D-01  -0.28080D-05  -0.25440D-03   0.30360D-05
Nav Base (IMU , Accelerom)       95602     0.12600D-04  -0.94400D-06  -0.12225D-01  -0.28080D-05  -0.25440D-03   0.30360D-05
Nav Base (IMU , Accelerom)       95602     0.12600D-04  -0.94400D-06  -0.12225D-01  -0.28080D-05  -0.25440D-03   0.30360D-05

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Nav Base (IMU , Accelerom)       95602     0.12600D-04  -0.94400D-06  -0.12225D-01
Nav Base (IMU , Accelerom)       95602     0.12600D-04  -0.94400D-06  -0.12225D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
Left  Booster Liquid Oxygen Sl   81602     0.46600D-05  -0.13400D-04  -0.13450D-01   0.39960D-04  -0.20400D-03   0.70800D-06
Right Booster Liquid Oxygen Sl   88603     0.67100D-05  -0.69100D-05  -0.13430D-01  -0.41760D-04  -0.19440D-03  -0.10920D-05

                              Node ID#     Modal Data at the Disturbance Point 
Nav Base (IMU , Accelerom)       95602     0.12600D-04  -0.94400D-06  -0.12225D-01  -0.28080D-05  -0.25440D-03   0.30360D-05

MODE # 4/  6, Frequency (rad/sec), Damping (zeta), Generalized Mass=    49.952       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  2 Engines, (x,y,z)...
Left  (-y) Boster Gimbal Locat   35701    -0.33000D-03  -0.44300D-03   0.31420D-01  -0.10044D-02   0.24120D-02  -0.12120D-05
Right (+y) Boster Gimbal Locat   45701     0.59500D-04  -0.85000D-03   0.31130D-01   0.97440D-03   0.24000D-02   0.28320D-04

                              Node ID#     Modal Data at the  3 Gyros ...
Nav Base (IMU , Accelerom)       95602     0.89200D-04  -0.85200D-03   0.69200D-01   0.59760D-04  -0.52440D-02  -0.12840D-03
Nav Base (IMU , Accelerom)       95602     0.89200D-04  -0.85200D-03   0.69200D-01   0.59760D-04  -0.52440D-02  -0.12840D-03
Nav Base (IMU , Accelerom)       95602     0.89200D-04  -0.85200D-03   0.69200D-01   0.59760D-04  -0.52440D-02  -0.12840D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Nav Base (IMU , Accelerom)       95602     0.89200D-04  -0.85200D-03   0.69200D-01
Nav Base (IMU , Accelerom)       95602     0.89200D-04  -0.85200D-03   0.69200D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
Left  Booster Liquid Oxygen Sl   81602     0.83400D-03  -0.72200D-04   0.34500D-01  -0.63600D-04  -0.63000D-02  -0.10092D-03
Right Booster Liquid Oxygen Sl   88603     0.10700D-03  -0.17000D-03   0.34200D-01   0.14520D-03  -0.59400D-02  -0.13080D-03

                              Node ID#     Modal Data at the Disturbance Point 
Nav Base (IMU , Accelerom)       95602     0.89200D-04  -0.85200D-03   0.69200D-01   0.59760D-04  -0.52440D-02  -0.12840D-03

MODE # 5/  8, Frequency (rad/sec), Damping (zeta), Generalized Mass=    59.510       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  2 Engines, (x,y,z)...
Left  (-y) Boster Gimbal Locat   35701     0.10600D-02   0.68800D-02   0.57600D-02   0.30000D-03   0.46680D-03  -0.41760D-03
Right (+y) Boster Gimbal Locat   45701    -0.11100D-02   0.67600D-02   0.61500D-02  -0.22200D-03   0.48960D-03  -0.42240D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Nav Base (IMU , Accelerom)       95602     0.57700D-04   0.65700D-02   0.57300D-02  -0.73080D-04  -0.58080D-03   0.91560D-03
Nav Base (IMU , Accelerom)       95602     0.57700D-04   0.65700D-02   0.57300D-02  -0.73080D-04  -0.58080D-03   0.91560D-03
Nav Base (IMU , Accelerom)       95602     0.57700D-04   0.65700D-02   0.57300D-02  -0.73080D-04  -0.58080D-03   0.91560D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Nav Base (IMU , Accelerom)       95602     0.57700D-04   0.65700D-02   0.57300D-02
Nav Base (IMU , Accelerom)       95602     0.57700D-04   0.65700D-02   0.57300D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
Left  Booster Liquid Oxygen Sl   81602    -0.27400D-02   0.56900D-03   0.16100D-02  -0.86400D-04  -0.61800D-03   0.96840D-03
Right Booster Liquid Oxygen Sl   88603     0.29400D-02   0.56300D-03   0.21800D-02  -0.60840D-04  -0.58200D-03   0.96720D-03

                              Node ID#     Modal Data at the Disturbance Point 
Nav Base (IMU , Accelerom)       95602     0.57700D-04   0.65700D-02   0.57300D-02  -0.73080D-04  -0.58080D-03   0.91560D-03

MODE # 6/  9, Frequency (rad/sec), Damping (zeta), Generalized Mass=    62.784       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  2 Engines, (x,y,z)...
Left  (-y) Boster Gimbal Locat   35701     0.36200D-02   0.20900D-01  -0.55600D-02   0.11640D-03  -0.45240D-03  -0.15480D-02
Right (+y) Boster Gimbal Locat   45701    -0.36600D-02   0.20800D-01  -0.19600D-02   0.11640D-03  -0.21600D-03  -0.15360D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Nav Base (IMU , Accelerom)       95602     0.14400D-03   0.47400D-01  -0.82100D-02  -0.37920D-03   0.15600D-03   0.15840D-02
Nav Base (IMU , Accelerom)       95602     0.14400D-03   0.47400D-01  -0.82100D-02  -0.37920D-03   0.15600D-03   0.15840D-02
Nav Base (IMU , Accelerom)       95602     0.14400D-03   0.47400D-01  -0.82100D-02  -0.37920D-03   0.15600D-03   0.15840D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Nav Base (IMU , Accelerom)       95602     0.14400D-03   0.47400D-01  -0.82100D-02
Nav Base (IMU , Accelerom)       95602     0.14400D-03   0.47400D-01  -0.82100D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
Left  Booster Liquid Oxygen Sl   81602    -0.11800D-01   0.29000D-01  -0.80200D-02  -0.34560D-03   0.62040D-03   0.40920D-02
Right Booster Liquid Oxygen Sl   88603     0.11900D-01   0.29000D-01  -0.53900D-02  -0.38400D-03   0.57720D-03   0.41040D-02

                              Node ID#     Modal Data at the Disturbance Point 
Nav Base (IMU , Accelerom)       95602     0.14400D-03   0.47400D-01  -0.82100D-02  -0.37920D-03   0.15600D-03   0.15840D-02

MODE # 7/ 12, Frequency (rad/sec), Damping (zeta), Generalized Mass=    96.019       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  2 Engines, (x,y,z)...
Left  (-y) Boster Gimbal Locat   35701     0.13800D-03   0.26000D-02  -0.32400D-02  -0.32880D-02   0.27000D-03  -0.16920D-03
Right (+y) Boster Gimbal Locat   45701    -0.17800D-03   0.22700D-02  -0.10780D-01  -0.46560D-03  -0.84480D-03  -0.12360D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Nav Base (IMU , Accelerom)       95602     0.15300D-03   0.23500D-02   0.28200D-02  -0.14640D-02  -0.55560D-02  -0.12360D-02
Nav Base (IMU , Accelerom)       95602     0.15300D-03   0.23500D-02   0.28200D-02  -0.14640D-02  -0.55560D-02  -0.12360D-02
Nav Base (IMU , Accelerom)       95602     0.15300D-03   0.23500D-02   0.28200D-02  -0.14640D-02  -0.55560D-02  -0.12360D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Nav Base (IMU , Accelerom)       95602     0.15300D-03   0.23500D-02   0.28200D-02
Nav Base (IMU , Accelerom)       95602     0.15300D-03   0.23500D-02   0.28200D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
Left  Booster Liquid Oxygen Sl   81602     0.11800D-02   0.95900D-02  -0.32700D-01  -0.62160D-03  -0.23400D-02  -0.41160D-03
Right Booster Liquid Oxygen Sl   88603    -0.13400D-02   0.95900D-02  -0.27970D-01  -0.98160D-03  -0.23640D-02  -0.39360D-03

                              Node ID#     Modal Data at the Disturbance Point 
Nav Base (IMU , Accelerom)       95602     0.15300D-03   0.23500D-02   0.28200D-02  -0.14640D-02  -0.55560D-02  -0.12360D-02

MODE # 8/ 13, Frequency (rad/sec), Damping (zeta), Generalized Mass=    109.77       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  2 Engines, (x,y,z)...
Left  (-y) Boster Gimbal Locat   35701     0.54000D-03   0.15100D-01   0.20300D-01  -0.90840D-02   0.33600D-02  -0.67200D-03
Right (+y) Boster Gimbal Locat   45701     0.58000D-03  -0.13700D-01   0.15000D-01   0.78720D-02   0.26400D-02   0.46800D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Nav Base (IMU , Accelerom)       95602    -0.34000D-02  -0.45100D-03   0.13900D-01  -0.15000D-02   0.55440D-03  -0.46200D-03
Nav Base (IMU , Accelerom)       95602    -0.34000D-02  -0.45100D-03   0.13900D-01  -0.15000D-02   0.55440D-03  -0.46200D-03
Nav Base (IMU , Accelerom)       95602    -0.34000D-02  -0.45100D-03   0.13900D-01  -0.15000D-02   0.55440D-03  -0.46200D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Nav Base (IMU , Accelerom)       95602    -0.34000D-02  -0.45100D-03   0.13900D-01
Nav Base (IMU , Accelerom)       95602    -0.34000D-02  -0.45100D-03   0.13900D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
Left  Booster Liquid Oxygen Sl   81602    -0.21000D-02   0.29000D-02   0.10000D-01  -0.14040D-02  -0.18000D-02  -0.26400D-03
Right Booster Liquid Oxygen Sl   88603    -0.37000D-02   0.27000D-02   0.19100D-01  -0.11088D-02  -0.15600D-02  -0.28800D-03

                              Node ID#     Modal Data at the Disturbance Point 
Nav Base (IMU , Accelerom)       95602    -0.34000D-02  -0.45100D-03   0.13900D-01  -0.15000D-02   0.55440D-03  -0.46200D-03
----------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Zulu, Stage-1, Max-Q, 8 Flex Modes with Slosh, Pitch Axis                                    
Zulu, Stage-1, Max-Q, 8 Flex Modes with Slosh                                                
! Pitch flexible system is extracted from the coupled system above 
! to be used in Matlab/Simulink Simulations                
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   1   2   3   4   9
Extract States :   3   4   7  11  12  13  14  15  16  17  18  19  20  21  22  23  24  25  26  27  29  31  33
Extract Outputs:   3   4   7  13  16  17  18
----------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Alpha Estimator                                                                                     
! This filter estimates the angle of attack in (radians) from the accelerometer measurement and     
! the gimbal deflection angle. It basically solves the normal force equation for alpha. The 
! inputs are (a) Nz measurement from the accelerometer, (b) Pitch rate to counteract against the 
! rotational component picked up by the accelerometer, (c) gimbal deflection to estimate the 
! normal component of thrust. The washout filter differentiates the rate gyro signal at low 
! frequencies.
Continuous                    
TF. Block #  1 Integrator                                        Order of Numer, Denom=   0  1                
Numer 0.0     1.0                                                                                                       
Denom 1.0     0.0                                                                                                    
TF. Block #  2 Washout Filter                                    Order of Numer, Denom=   1  1                
Numer 80.0    0.0                                                                                                       
Denom 1.0    17.0                                                                                                    
TF. Block #  3 Notch 50 rad                                      Order of Numer, Denom=   2  2                
Numer 1.0     5.0    2500.0                                                                                                 
Denom 1.0    50.0    2500.0                                                                                          
TF. Block #  4 Notch 21.2 rad                                    Order of Numer, Denom=   2  2                
Numer 1.0    2.12    449.44                                                                                                 
Denom 1.0    21.2    449.44                                                                                          
....................................................................................................
Block #, from Input #, Gain
   3   1    1.0             {TF:  3, Notch 50    } from {Nz Acceleration}       1
   1   2   -617620.0        {TF:  1, Integrator  } from {Gimbal Deflection}     2*Thrust 
   2   3    1.0             {TF:  2, Washout Filt} from {Pitch Rate Gyro}       1
...........................
Outpt #, from Block #, Gain
   1   1   0.1745000E-01    {System Output  1    } from {TF:  1, Integrator  }  d2r
...........................
Block #, from Block #, Gain
   1   1   -3699.0          {TF:  1, Integrator  } from {TF:  1, Integrator  }  Q*Sref*Cza
   1   2   -9580.0          {TF:  1, Integrator  } from {TF:  2, Washout Filt}  Mass
   1   4   -9580.0          {TF:  1, Integrator  } from {TF:  4, Notch 21    }  Mass
   4   3    1.0             {TF:  3, Notch 21    } from {TF:  3, Notch 50    }  1
...........................
Definitions of Inputs  =   3
Nz Acceleration (ft/sec^2)                                                      
Gimbal Deflection, Delta (rad)       
Pitch Rate Gyro, q-flex (rad/sec)                                           
 
Definitions of Outputs =   1
Alpha Estimate in (radians)                                                     
----------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Pitch Flight Control System                                                                            
! This is the state-feedback pitch FCS with filters and actuator combined
! The attitude, pitch rate and gamma come from the vehicle subsystem. The
! angle of attack comes from the alpha estimator. The output goes to the 
! vehicle gimbal deflection input.
Continuous                    
TF. Block #  1 Gamma Integrat                                    Order of Numer, Denom=   0  1                
Numer 0.0    1.0                                                                                                       
Denom 1.0    0.0                                                                                                    
TF. Block #  2 Low-Pass Filter                                   Order of Numer, Denom=   0  2                
Numer 0.0    0.0    324.0                                                                                                    
Denom 1.0    19.8   324.0                                                                                                    
....................................................................................................
Block #, from Input #, Gain
   2   1    1.6             {TF: 2, Filter} from {Theta Error}  
   2   2    0.4             {TF: 2, Filter} from {Pitch Rate Gyro}  
   2   3   -0.0381          {TF: 2, Filter} from {Alpha}  
   1   4    1.0             {TF: 1, Integrator} from {Gamma Error}  
...........................
Outpt #, from Block #, Gain
   1   2    1.0             {Gimbal Deflect} from {TF: 2, Filter}  
...........................
Block #, from Block #, Gain
   2   1    0.047           {TF: 2, Filter} from {TF: 1, Gamma Integral}  
...........................
Definitions of Inputs  =   4
Theta error (Theta-Thetcom) (rad)                                                      
Pitch rate gyro (rad/sec)       
Alpha (rad)        
Gamma error (Gamma-Gamcom) (rad)                                   
 
Definitions of Outputs =   1
Gimbal Deflection (radians)                                                     
----------------------------------------------------------------------------------------------------------------------------
ACTUATOR INPUT DATA ............ SIMPLE GENERIC MODEL     
Engine TVC Actuator
Symbol Parameter Description                    (Units)      Value 
C(s)   Order of Compensat:(0,1,2), Coefficients   (---)      1, 0.005, 0.05
Kc     Input Command Gain ..................... (volt/rad)   3.0    
Ka     Gain of Amplifier ...................... (amps/volt)  60.0    
Ksv    Closed-Loop Actuator Servo Gain ....... (ft/sec/amp)  1.0
Kact   Actuator Stiffness (Piston+Oil+Electric) (lb/ft)      0.48e+8
Klod   Load Stiffness,(Con. Surface or Nozzle)  (lb/ft)      0.36e+10
Kbck   Vehicle Backup Structure Stiffness ....  (lb/ft)      0.84e+10
R      Moment Arm of Actuator Rod from Gimbal..  (feet)      3.0
Jl     Load Inertia about the Gimbal .......... (ft-lb-s^2)  3200.0
Kg     Load Gimbal Bearing Spring Constant      (ft-lb/rad)  0.0000    
Bg     Load Gimbal Bearing Viscous Damping .... (ft-lb-sec)  75000.0
Kfb    Actuator Position Feedback Gain ........ (volts/ft)   1.0
----------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Pitch Open-Loop System                                                                            
! Open-Loop System obtained using the Flixan system building utilities 
! to be used for Frequency Response Analysis                                                               
Titles of Systems to be Combined
Title 1 Zulu, Stage-1, Max-Q, 8 Flex Modes with Slosh, Pitch Axis                                           
Title 2 Alpha Estimator                                                                                     
Title 3 Pitch Flight Control System                                                                         
Title 4 Engine TVC Actuator
SYSTEM INPUTS TO SUBSYSTEM  4                                              Actuator
System Input  1 to Subsystem  4, Input  1, Gain=  1.0000                   Pitch Gimbal Command
......................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  3                                           Flight Control System
System Output  1 from Subsystem  3, Output  1, Gain=  -1.0000              from filter
......................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  3                                    Vehicle to Controller
Subsystem  1, Output  1 to Subsystem  3, Input  1, Gain=   1.0000          Attitude Theta
Subsystem  1, Output  4 to Subsystem  3, Input  2, Gain=   1.0000          q-flex
Subsystem  1, Output  1 to Subsystem  3, Input  4, Gain=   1.0000          Gamma= Theta
Subsystem  1, Output  3 to Subsystem  3, Input  4, Gain=  -1.0000                -Alpha
......................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  2                                    Vehicle to Estimator
Subsystem  1, Output  4 to Subsystem  2, Input  3, Gain=   1.0000          q-flex
Subsystem  1, Output  5 to Subsystem  2, Input  1, Gain=   1.0000          Nz
......................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  3                                    Estimator to Controller
Subsystem  2, Output  1 to Subsystem  3, Input  3, Gain=   1.0000          Alpha-Estimate
......................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  4                                    Vehicle to Actuator
Subsystem  1, Output  6 to Subsystem  4, Input  2, Gain=   0.5             Load-Torque
Subsystem  1, Output  7 to Subsystem  4, Input  2, Gain=   0.5             Load-Torque
......................................................................
SUBSYSTEM NO  4 GOES TO SUBSYSTEM NO  1                                    Actuator to Vehicle
Subsystem  4, Output  1 to Subsystem  1, Input  1, Gain=   1.0000          Pitch Gimbal-1
Subsystem  4, Output  1 to Subsystem  1, Input  2, Gain=   1.0000          Pitch Gimbal-2
Subsystem  4, Output  2 to Subsystem  1, Input  3, Gain=   1.0000          Pitch Gimbal accel-1
Subsystem  4, Output  2 to Subsystem  1, Input  4, Gain=   1.0000          Pitch Gimbal accel-2
......................................................................
SUBSYSTEM NO  4 GOES TO SUBSYSTEM NO  2                                    Actuator to Estimator         
Subsystem  4, Output  1 to Subsystem  2, Input  2, Gain=   1.0000          Pitch Gimbal
......................................................................
Definitions of Inputs  =   1
Gimbal In                                                             
 
Definitions of Outputs =   1
FCS Out
----------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Pitch Closed-Loop System                                                                            
! Closed-Loop System obtained using the Flixan system building utilities 
! to be used for Simulations                                                               
Titles of Systems to be Combined
Title 1 Zulu, Stage-1, Max-Q, 8 Flex Modes with Slosh, Pitch Axis                                           
Title 2 Alpha Estimator                                                                                     
Title 3 Pitch Flight Control System                                                                         
Title 4 Engine TVC Actuator
SYSTEM INPUTS TO SUBSYSTEM  3                                              Pitch Flight Control System                  
System Input  1 to Subsystem  3, Input  1, Gain=  -1.0000                  Theta Command
System Input  2 to Subsystem  3, Input  4, Gain=  -1.0000                  Gamma Command
......................................................................
SYSTEM INPUTS TO SUBSYSTEM  1                                              Vehicle Model
System Input  3 to Subsystem  1, Input  5, Gain=   1.0000                  Wind Gust (ft/sec)
......................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                           Vehicle Model
System Output  1 from Subsystem  1, Output  1, Gain=   1.0000              Theta
System Output  2 from Subsystem  1, Output  4, Gain=   1.0000              q-flex (rate gyro)
System Output  3 from Subsystem  1, Output  3, Gain=   1.0000              Alpha
System Output  5 from Subsystem  1, Output  1, Gain=   1.0000              Gamma= Theta
System Output  5 from Subsystem  1, Output  3, Gain=  -1.0000                    -Alpha
System Output  6 from Subsystem  1, Output  5, Gain=   1.0000              Nz accelerom
......................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                           Alpha Estimator                              
System Output  4 from Subsystem  2, Output  1, Gain=   1.0000              Alpha-Hat
......................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  4                                           Actuator
System Output  7 from Subsystem  4, Output  1, Gain=   1.0000              Gimbal deflect (rad) 
......................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  3                                    Vehicle to Controller
Subsystem  1, Output  1 to Subsystem  3, Input  1, Gain=   1.0000          Attitude Theta
Subsystem  1, Output  4 to Subsystem  3, Input  2, Gain=   1.0000          q-flex
Subsystem  1, Output  1 to Subsystem  3, Input  4, Gain=   1.0000          Gamma= Theta
Subsystem  1, Output  3 to Subsystem  3, Input  4, Gain=  -1.0000                -Alpha
......................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  2                                    Vehicle to Estimator
Subsystem  1, Output  4 to Subsystem  2, Input  3, Gain=   1.0000          q-flex
Subsystem  1, Output  5 to Subsystem  2, Input  1, Gain=   1.0000          Nz
......................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  4                                    Vehicle to Actuator
Subsystem  1, Output  6 to Subsystem  4, Input  2, Gain=   0.5             Load-Torque
Subsystem  1, Output  7 to Subsystem  4, Input  2, Gain=   0.5             Load-Torque
......................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  3                                    Estimator to Controller
Subsystem  2, Output  1 to Subsystem  3, Input  3, Gain=   1.0000          Alpha-Estimate
......................................................................
SUBSYSTEM NO  3 GOES TO SUBSYSTEM NO  4                                    Control Syst to Actuator
Subsystem  3, Output  1 to Subsystem  4, Input  1, Gain=   1.0000          Delta_y
......................................................................
SUBSYSTEM NO  4 GOES TO SUBSYSTEM NO  1                                    Actuator to Vehicle
Subsystem  4, Output  1 to Subsystem  1, Input  1, Gain=   1.0000          Pitch Gimbal-1
Subsystem  4, Output  1 to Subsystem  1, Input  2, Gain=   1.0000          Pitch Gimbal-2
Subsystem  4, Output  2 to Subsystem  1, Input  3, Gain=   1.0000          Pitch Gimbal accel-1
Subsystem  4, Output  2 to Subsystem  1, Input  4, Gain=   1.0000          Pitch Gimbal accel-2
......................................................................
SUBSYSTEM NO  4 GOES TO SUBSYSTEM NO  2                                    Actuator to Estimator         
Subsystem  4, Output  1 to Subsystem  2, Input  2, Gain=   1.0000          Pitch Gimbal
......................................................................
Definitions of Inputs  =   3
Theta Command (rad)                                                             
Gamma Command (rad)                                                             
Wind Gust Veloc. (ft/sec)                                                       
 
Definitions of Outputs =   7
Theta (rad)                                                                     
Pitch Rate (rad/sec)                                                            
Alpha (rad)                                                                     
Alpha Estimate (rad)                                                            
Gamma (rad)                                                                     
Normal Accelerometer, Nz (ft/sec^2)                                             
Gimbal Deflection (rad)                                                         
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Zulu, Stage-1, Max-Q, Rigid Body, Pitch Axis
System
Vehi_Pitch_rb
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Zulu, Stage-1, Max-Q, 8 Flex Modes with Slosh, Pitch Axis 
System
Vehi_Pitch_SFlx
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Alpha Estimator
System
Estimator
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Pitch Flight Control System
System
pitch_fcs
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Engine TVC Actuator
System
Actuator
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Pitch Open-Loop System
System
open_loop
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Pitch Closed-Loop System
System
closed_loop
------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
