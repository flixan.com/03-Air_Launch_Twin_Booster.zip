BATCH MODE INSTRUCTIONS ...............                                                             
Batch for calculating the Zulu Rocket files at Stage-2 Ignition
! This batch set creates a state-space model for a rigid Zulu rocket during second stage
! at T=92 sec and also the Mixing Logic Matrix. Then it extracts the longitudinal 
! and lateral subsystems for control design. 
! 
Flight Vehicle   : Zulu, Stage-2, T92
Mixing Matrix    : Mixing Logic Matrix for the Second Stage Zulu Rocket
System Connection: Vehicle and Kmix Combined System 
System Modificat : Zulu, Stage-2, T92, Pitch Design Model 
System Modificat : Zulu, Stage-2, T92, Lateral Design Model 
!
To Matlab Format : Mixing Logic Matrix for the Second Stage Zulu Rocket
To Matlab Format : Zulu, Stage-2, T92
To Matlab Format : Zulu, Stage-2, T92, Pitch Design Model 
To Matlab Format : Zulu, Stage-2, T92, Lateral Design Model 
----------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Zulu, Stage-2, T92
! Data for the Zulu Launch Vehicle during Second Stage at Engine Ignition.
Body Axes Output,Attitude=Euler Angles,Without GAFD, No Turn Coordination  
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   5295.70       32.1740      0.208960E+08
Moments and Products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   39202.2      0.131089E+07  0.131119E+07  -662.342       3738.72       441.925    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :  -222.969       0.0           0.013026
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   4.84600       5076.70       14.6900       178184.    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   49.7786       65.4830       0.00000       0.40300    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :  -0.72400       0.00000       1.30616       0.00000    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.00000       29.0610       0.00000       0.00000       1.06900       0.00000    
W-Gust Azim & Elev angles (deg), or Torque/Force direction (x,y,z), Force Locat (x,y,z)  :   Gust          45.0000       90.0000                                             
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   47.3080       7.76100       7.76100    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :  -204.090       0.00000       0.00000       0.00000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.411072      -0.0021       -0.191688E-04   0.00000       0.00000       0.00000       0.00000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.00000      -0.0457        0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:  0.131206      -0.0731        0.00000       0.00000       0.00000       0.00000     -0.194326E-04
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.00000      -0.0028        0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}: -0.644616       0.3888        0.00000       0.00000       0.00000      0.113342E-03   0.00000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.00000      -0.2531        0.00000       0.00000       0.00000       0.00000    

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  3   NO TWD  

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : Middle TVC       Gimbaling   
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   347070.       347070.    
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   0.00000       0.00000       5.00000       5.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   47.0000       260.000       0.20000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  -244.620       0.00000       0.00000    
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : Left RCS Jet     Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   0.00000       800.000    
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   90.0000       0.00000       0.00000       0.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   0.00000       0.00000       0.00000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  -120.000      -4.00000       0.00000    
TVC Engine No:  3                                (Gimbaling  Throttling   Single_Gimbal) : Rght RCS Jet     Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   0.00000       800.000    
Trim Angles (Dyn,Dzn) wrt Vehicle x-axis, Maxim Deflections (Dymax,Dzmax) from Trim (deg):   90.0000       0.00000       0.00000       0.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   0.00000       0.00000       0.00000    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  -120.000       4.00000       0.00000    

Number of Accelerometers, Along Axis: (x,y,z)                                            :  3
Acceleromet No  1 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  X-axis Accelerat.     -222.969      -0.300429E-02   0.130257E-01
Acceleromet No  2 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Y-axis Accelerat.     -222.969      -0.300429E-02   0.130257E-01
Acceleromet No  3 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Z-axis Accelerat.     -222.969      -0.300429E-02   0.130257E-01
----------------------------------------------------------------------------------------------------------------------------
MIXING LOGIC MATRIX DATA ..........    (Matrix Title, Name, Vehicle Title, Control Directions)
Mixing Logic Matrix for the Second Stage Zulu Rocket
! Mixing Logic Matrix for the Zulu Rocket at Second Stage 
Kmix
Zulu, Stage-2, T92
P-dot Roll  Acceleration About X Axis                                           
Q-dot Pitch Acceleration About Y Axis                                           
R-dot Yaw   Acceleration About Z Axis                                           
----------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Vehicle and Kmix Combined System 
! Combine Vehicle Model with Kmix in front to be used in the LQR design           
Titles of Systems to be Combined  
Title 1 Zulu, Stage-2, T92
SYSTEM INPUTS TO SUBSYSTEM  1
Via Matrix +Kmix                                                                The (4x2) Mixing Logic Matrix
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                Lateral State-Vector Outputs
Via Matrix +I8
..............................................................................
Definitions of Inputs  =   3
P-dot Roll  Acceleration About X Axis                                           
Q-dot Pitch Acceleration About Y Axis                                           
R-dot Yaw   Acceleration About Z Axis                                           
 
Definitions of Outputs =   8
Roll Attitude  (phi-body) (radians)                                                          
Roll Rate      (p-body)   (rad/sec)                                                          
Ptch Attitude  (theta-body) (radians)                                                   
Ptch Rate      (q-body)   (rad/sec)                                                   
Yaw  Attitude  (psi-body) (radians)                                                          
Yaw  Rate      (r-body)   (rad/sec)                                                          
Angle of Attack,  alpha, (radians)                                                            
Angle of Sideslip, beta, (radians)                                                   
-----------------------------------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Zulu, Stage-2, T92, Pitch Design Model 
Vehicle and Kmix Combined System 
! Pitch rigid system is extracted from the coupled rigid system above                                      
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   2
Extract States :   3   4   7 
Extract Outputs:   3   4   7 
----------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Zulu, Stage-2, T92, Lateral Design Model 
Vehicle and Kmix Combined System 
! The lateral rigid body system is extracted from the coupled RB system above                                     
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   1   3
Extract States :   1   2   5   6   8  
Extract Outputs:   1   2   5   6   8 
------------------------------------------------------------------------------------------------------------------------
                                  CREATE MATLAB DATA
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Mixing Logic Matrix for the Second Stage Zulu Rocket
Matrix Kmix
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Zulu, Stage-2, T92
System
Vehicle_rb
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Zulu, Stage-2, T92, Pitch Design Model 
System
Vehi_Pitch_Des
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Zulu, Stage-2, T92, Lateral Design Model 
System
Vehi_Later_Des
------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
