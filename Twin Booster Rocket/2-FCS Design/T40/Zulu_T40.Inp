BATCH MODE INSTRUCTIONS ...............                                                             
Batch for calculating the Closed-Loop model for a Zulu Rocket
! This batch set creates a state-space model for a rigid Zulu rocket during first stage
! at T=40 sec and also the Mixing Logic Matrix. Then it extracts the longitudinal 
! and lateral subsystems for control design. 
! 
Flight Vehicle   : Zulu, Stage-1, T40
Mixing Matrix    : Mixing Logic Matrix for the Twin Engine Zulu Rocket
System Connection: Vehicle and Kmix Combined System 
System Modificat : Zulu, Stage-1, T40, Pitch Design Model 
System Modificat : Zulu, Stage-1, T40, Lateral Design Model 
!
To Matlab Format : Mixing Logic Matrix for the Twin Engine Zulu Rocket
To Matlab Format : Zulu, Stage-1, T40
To Matlab Format : Zulu, Stage-1, T40, Pitch Design Model 
To Matlab Format : Zulu, Stage-1, T40, Lateral Design Model 
----------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Zulu, Stage-1, T40
! This is a Launch Vehicle during First Stage at t=40 sec from release.
Body Axes Output,Attitude=Euler Angles,No GAFD-Hpar, No Turn Coordination  
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   9580.00       32.1740      0.208960E+08
Moments and Products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   519316.      0.171345E+07  0.215335E+07  -671.961       3512.52       377.182    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :  -226.098       0.00000      0.692814E-02
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   1.94000       1870.00       228.000       71300.0    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   45.4546       75.0000       0.00000       1.30000    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :  -1.94000       0.00000      0.500001       0.00000    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.00000       48.1600       0.00000       0.00000     -0.225000       0.00000    
W-Gust Azim & Elev angles (deg), or Torque/Force direction (x,y,z), Force Locat (x,y,z)  :   Gust         45.0000       90.0000                                             
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   47.3080       7.76100       7.76100    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :  -228.190       0.00000       0.00000       0.00000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.750111      0.139999E-02  -0.182727E-03  0.00000       0.00000       0.00000       0.00000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.00000     -0.659400E-01   0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:  0.665643     -0.343600       0.00000       0.00000       0.00000       0.00000     -0.940912E-05
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.00000     -0.690000E-02   0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:  -1.30220      0.680650       0.00000       0.00000       0.00000      0.182591E-03   0.00000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.00000     -0.278360       0.00000       0.00000       0.00000       0.00000    

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  2   NO TWD

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : Left TVC         Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  363305.0      363305.0      
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.0           0.0          5.0          5.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   47.0         260.00       0.2  
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  -244.62      -8.67         0.0    
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : Right TVC        Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  363305.0      363305.0      
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.0           0.0          5.0          5.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   47.0         260.00       0.2  
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  -244.62       8.67         0.0                                     
-----------------------------------------------------------------------------------------------------------------------------------------------------
MIXING LOGIC MATRIX DATA ..........    (Matrix Title, Name, Vehicle Title, Control Directions)
Mixing Logic Matrix for the Twin Engine Zulu Rocket             
! Mixing Logic Matrix for the Twin Engine Zulu Rocket at Engine Ignition
Kmix
Zulu, Stage-1, T40
P-dot Roll  Acceleration About X Axis                                           
Q-dot Pitch Acceleration About Y Axis                                           
R-dot Yaw   Acceleration About Z Axis                                           
----------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Vehicle and Kmix Combined System 
! Combine Vehicle Model with Kmix in front to be used in the LQR design           
Titles of Systems to be Combined  
Title 1 Zulu, Stage-1, T40
SYSTEM INPUTS TO SUBSYSTEM  1
Via Matrix +Kmix                                                                The (4x2) Mixing Logic Matrix
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                Lateral State-Vector Outputs
Via Matrix +I8
..............................................................................
Definitions of Inputs  =   3
P-dot Roll  Acceleration About X Axis                                           
Q-dot Pitch Acceleration About Y Axis                                           
R-dot Yaw   Acceleration About Z Axis                                           
 
Definitions of Outputs =   8
Roll Attitude  (phi-body) (radians)                                                          
Roll Rate      (p-body)   (rad/sec)                                                          
Ptch Attitude  (theta-body) (radians)                                                   
Ptch Rate      (q-body)   (rad/sec)                                                   
Yaw  Attitude  (psi-body) (radians)                                                          
Yaw  Rate      (r-body)   (rad/sec)                                                          
Angle of Attack,  alpha, (radians)                                                            
Angle of Sideslip, beta, (radians)                                                   
-----------------------------------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Zulu, Stage-1, T40, Pitch Design Model 
Vehicle and Kmix Combined System 
! Pitch rigid system is extracted from the coupled rigid system above                                      
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   2
Extract States :   3   4   7 
Extract Outputs:   3   4   7 
----------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Zulu, Stage-1, T40, Lateral Design Model 
Vehicle and Kmix Combined System 
! The lateral rigid body system is extracted from the coupled RB system above                                     
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   1   3
Extract States :   1   2   5   6   8  
Extract Outputs:   1   2   5   6   8 
------------------------------------------------------------------------------------------------------------------------
                                  CREATE MATLAB DATA
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Mixing Logic Matrix for the Twin Engine Zulu Rocket
Matrix Kmix
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Zulu, Stage-1, T40
System
Vehicle_rb
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Zulu, Stage-1, T40, Pitch Design Model 
System
Vehi_Pitch_Des
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Zulu, Stage-1, T40, Lateral Design Model 
System
Vehi_Later_Des
------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
